# Keil uVision project test_uicr_write.uvprojx, settings and files
target nRF52832 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_uicr_write +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: NRF52
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group test
    ./: main.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
